Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2024-01-16T15:41:53
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jan 16 15:41:53 2024 * Host: DEGTL11901 * Database: C:\Users\deschvi\AppData\Local\Temp\0b9b0487-4a8d-4ea9-bd74-5b674b5e9397\1d27da90-6f7f-41a0-9007-80b2e1d30306\ifc * Database version: 5507 * Database creation date: Tue Jan 16 15:41:53 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Jan 16 15:41:53 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jan 16 15:41:53 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12155070_SER_H2861BP_OBSW:22286125_SER_12155070_H2861BP_OBSW, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom
Type - Pset_BuildingElementProxyCommon - Reference: 22286125_SER_12155070_H2861BP_OBSW
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 22286125_SER_12155070_H2861BP_OBSW
Type - Pset_ProvisionForVoid - Depth: 568 mm
Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_OBSW, z_Miele_Design_Glass Black, z_Miele_Connection_Electric, z_Miele_Design_Zinc_Steel
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Width: 595 mm; Height: 596 mm

# IfcDistributionPort, Port_353920
Description: Flow; FlowDirection: SOURCEANDSINK
